# Keil uVision project STM32_CAN_CMD.uvprojx, settings and files
target STM32_PUL_WHILE (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x00005000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_STDPERIPH_DRIVER
  c include: ..\APP;..\BSP;..\CMSIS;..\LIB\STM32F10x_StdPeriph_Lib_V3.5.0\inc;..\DRIVERS;..\LIB\STM32F10x_StdPeriph_Lib_V3.5.0\src
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group APP
    ../APP/: main.c stm32f10x_conf.h stm32f10x_it.c stm32f10x_tim.c stm32f10x_tim.h
  group BSP
    ../BSP/: Emm_V5.c Emm_V5.h can.c can.h board.c board.h Protocol.c Protocol.h Usart1.c Usart1.h cybergear1.c cybergear1.h Miparam.h Mycan.c Mycan.h PID.c PID.h Timer.c Timer.h Chassis.c Chassis.h Feedback.c Feedback.h
  group CMSIS
    ../CMSIS/: core_cm3.c startup_stm32f10x_hd.s system_stm32f10x.c
  group DRIVERS
    ../DRIVERS/: fifo.c fifo.h delay.c delay.h
  group STM32F10x_StdPeriph_Lib_V3.5.0
    ../LIB/STM32F10x_StdPeriph_Lib_V3.5.0/src/: stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_can.c misc.c stm32f10x_usart.c
